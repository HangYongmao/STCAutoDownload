# Keil uVision project STCAutoDownload.uvproj, settings and files
target STC自动下载器 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: STCAutoDownload +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: main.c
